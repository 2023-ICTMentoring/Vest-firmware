# Keil uVision project MINI54FDE.uvprojx, settings and files
target mini54FDE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: Mini54FDE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.18
  cpu: IRAM(0x20000000,0x800) IROM(0x00000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: MINI54FDE
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\;..\Mini51DE_CMSIS_V301002
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group ASMLIB
    ../Mini51DE_CMSIS_V301002/: startup_Mini51Series.s system_Mini51Series.c clk.c adc.c gpio.c sys.c timer.c uart.c
  group Source
    ./: Mini54FDE.c
  group Document
    ../: E3355_하드웨어정보.txt 개발mini54FDE_버젼관리.txt
