# Keil uVision project Project.uvprojx, settings and files
target Project1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: NUC130LC1CN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.18
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\;..\NUC130_CMSIS308_LIBRARY
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group ASMLIB
    ../NUC130_CMSIS308_LIBRARY/: startup_NUC1xx.s system_NUC100Series.c clk.c gpio.c sys.c timer.c uart.c adc.c
  group Source
    ./: NUC130LC1CN.c
  group 읽어두기
    ../: FDe_프로젝트읽어두기.txt
